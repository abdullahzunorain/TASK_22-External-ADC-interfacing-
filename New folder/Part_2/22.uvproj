# Keil uVision project 22.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 22 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC.h ADC.c LCD.c LCD.h main.c
